Commit message: gripper

File: arm_dm_description/urdf/arm_dm_description.urdf (robot description, URDF)
Before this commit: robot arm_dm_description, 7 links, 6 joints
Joints:
- joint joint6: limit lower=-1.57 upper=1.57 effort=26 velocity=10 -> lower=0 upper=1.1 effort=26 velocity=10
